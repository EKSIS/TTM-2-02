# IAR project ttm-2.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: Y:\Programs\Service\MSP430; Y:\Programs\Service\ARM\LPC
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: N:\Exchange\Антонов Александр\Проекты IAR\TTM-2-02-OKW_L\lnk430F5529_ttm2_okw.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group main
    ./: define.h eevar_initial__.c global_var.c ini.c ini__.c interrupts.c interrupts__.c lcd__.c lcd_main.c main.c memf.c printf.c prog.c usb_descriptors.c usb_msp.c
